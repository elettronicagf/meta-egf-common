SRC_URI = "https://src.fedoraproject.org/repo/pkgs/libxslt/libxslt-${PV}.tar.gz \
           file://pkgconfig_fix.patch \
           file://pkgconfig.patch \
           file://CVE-2015-7995.patch"

